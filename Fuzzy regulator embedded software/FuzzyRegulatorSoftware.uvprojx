# Keil uVision project FuzzyRegulatorSoftware.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MDR32F9Q2I Milandr
  pack: Milandr.MDR32FxQI.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FuzzyRegulatorSoftware
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\RTE\Device\MDR32F9Q2I\MDR32F9Q2I.sct
  group src
    ./src/: clock.h current_sensor.h fuzzy_regulator.h fxd_pnt_math.h i2c.h main.h mb.h mbascii.h mbconfig.h mbcrc.h mbframe.h mbfunc.h mbport.h mbproto.h mbregmap.h mbrtu.h mbutils.h motor_control.h port.h uart.h clock.c current_sensor.c fuzzy_regulator.c i2c.c main.c mb.c mbascii.c mbcrc.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbutils.c motor_control.c portevent.c portserial.c porttimer.c uart.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.0.2i, Drivers:I2C 2.0.2i, Drivers:PORT 2.0.2i, Drivers:RST_CLK 2.0.2i, Drivers:SSP 2.0.2i, Drivers:TIMER 2.0.2i, Drivers:UART 2.0.2i
